# Autodesk Inventor assembly: Fuehrung-pa
## iProperties
Created: 2012-11
Part Number: Fuehrung-pa
Document SubType Name: Assembly
Designer: Palme
Author: Palme
